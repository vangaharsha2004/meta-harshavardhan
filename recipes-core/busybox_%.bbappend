FILESEXTRAPATHS:prepend :="${THISDIR}/files/:"

SRC_URI:appened=" file://fragment.cfg"

